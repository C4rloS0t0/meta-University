# Append for agl-cluster-demo-platform build image 

IMAGE_INSTALL += "ServiceApp ServiceAppcpp"